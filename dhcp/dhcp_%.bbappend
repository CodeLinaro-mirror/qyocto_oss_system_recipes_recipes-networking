
FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += "file://dhcpd.conf \
            file://default-server"
