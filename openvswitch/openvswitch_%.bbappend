LICENSE = "GPLv2+"

SRC_URI += "file://0009-set_master_for_vport.patch \
	    "

FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

